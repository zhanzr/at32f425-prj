# Keil uVision project atf425_prj.uvprojx, settings and files
target ATSTART_F425_V1 (6160000::V6.16::ARMCLANG)
  device: -AT32F425R8T7-7 ArteryTek
  pack: ArteryTek.AT32F425_DFP.2.0.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: atf425_prj
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F425R8T7,USE_STDPERIPH_DRIVER,AT_START_F425_V1
  c include: .\Source\custom_bsp;.\Source;.\Source\generated_clock_code\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ./Source/: main.c f425_it.c crc32_soft.c
  group custom_bsp
    ./Source/custom_bsp/: custom_at32f425_board.c
  group generated_clock_config
    ./Source/generated_clock_code/src/: at32f425_clock.c
software components: CMSIS:CORE 5.5.0, Device:at32f425_conf 2.0.0, Device:at32f425_firmware_library:adc 2.0.0, Device:at32f425_firmware_library:crc 2.0.0, Device:at32f425_firmware_library:crm 2.0.0, Device:at32f425_firmware_library:debug 2.0.0, Device:at32f425_firmware_library:dma 2.0.0, Device:at32f425_firmware_library:exint 2.0.0, Device:at32f425_firmware_library:gpio 2.0.0, Device:at32f425_firmware_library:misc 2.0.0, Device:at32f425_firmware_library:scfg 2.0.0, Device:at32f425_firmware_library:usart 2.0.0, Device:startup 2.0.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0
